## driver/pn54x/Kconfig
```kconfig
config PN54X
  tristate "pn54x simulator driver"
  default n
  help
  This is the pn54x simulator driver
```
